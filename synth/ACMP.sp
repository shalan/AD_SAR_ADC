* SPICE netlist generated by Yosys 0.9 (git sha1 UNKNOWN, clang 12.0.0 -fPIC -Os)

.SUBCKT ACMP clk INP INN VDD VSS Q VGND VNB VPB VPWR
X0 INN INN clk VSS net3 VGND VNB VPB VPWR net4 sky130_fd_sc_hd__o221ai_1
X1 INN INN clkb VDD net1 VGND VNB VPB VPWR net2 sky130_fd_sc_hd__a221oi_1
X2 INP INP clkb VDD net2 VGND VNB VPB VPWR net1 sky130_fd_sc_hd__a221oi_1
X3 INP INP clk VSS net4 VGND VNB VPB VPWR net3 sky130_fd_sc_hd__o221ai_1
X4 net4 VGND VNB VPB VPWR net5 sky130_fd_sc_hd__inv_1
X5 net3 VGND VNB VPB VPWR net6 sky130_fd_sc_hd__inv_1
X6 clk VGND VNB VPB VPWR clkb sky130_fd_sc_hd__inv_1
X7 Q net6 net2 VGND VNB VPB VPWR net7 sky130_fd_sc_hd__nor3_1
X8 net5 net1 net7 VGND VNB VPB VPWR Q sky130_fd_sc_hd__nor3_1
.ENDS ACMP

************************
* end of SPICE netlist *
************************
