* SPICE netlist generated by Yosys 0.9 (git sha1 UNKNOWN, clang 12.0.0 -fPIC -Os)

.SUBCKT SAR clk rst start cmp out.0 out.1 out.2 out.3 out.4 out.5 out.6 out.7 outn.0 outn.1 outn.2 outn.3 outn.4 outn.5 outn.6 outn.7 done clkn VGND VNB VPB VPWR
X0 clk _018_ _021_ VGND VNB VPB VPWR state_2_ sky130_fd_sc_hd__dfrtp_4
X1 clk _016_ _020_ VGND VNB VPB VPWR done sky130_fd_sc_hd__dfrtp_4
X2 clk _017_ _019_ VGND VNB VPB VPWR state_0_ sky130_fd_sc_hd__dfstp_4
X3 clk _015_ VGND VNB VPB VPWR next_6_ sky130_fd_sc_hd__dfxtp_4
X4 clk _014_ VGND VNB VPB VPWR next_5_ sky130_fd_sc_hd__dfxtp_4
X5 clk _013_ VGND VNB VPB VPWR next_4_ sky130_fd_sc_hd__dfxtp_4
X6 clk _012_ VGND VNB VPB VPWR next_3_ sky130_fd_sc_hd__dfxtp_4
X7 clk _011_ VGND VNB VPB VPWR next_2_ sky130_fd_sc_hd__dfxtp_4
X8 clk _010_ VGND VNB VPB VPWR next_1_ sky130_fd_sc_hd__dfxtp_4
X9 clk _009_ VGND VNB VPB VPWR next_0_ sky130_fd_sc_hd__dfxtp_4
X10 clk _008_ VGND VNB VPB VPWR shift_0_ sky130_fd_sc_hd__dfxtp_4
X11 clk _007_ VGND VNB VPB VPWR out.7 sky130_fd_sc_hd__dfxtp_4
X12 clk _006_ VGND VNB VPB VPWR out.6 sky130_fd_sc_hd__dfxtp_4
X13 clk _005_ VGND VNB VPB VPWR out.5 sky130_fd_sc_hd__dfxtp_4
X14 clk _004_ VGND VNB VPB VPWR out.4 sky130_fd_sc_hd__dfxtp_4
X15 clk _003_ VGND VNB VPB VPWR out.3 sky130_fd_sc_hd__dfxtp_4
X16 clk _002_ VGND VNB VPB VPWR out.2 sky130_fd_sc_hd__dfxtp_4
X17 clk _001_ VGND VNB VPB VPWR out.1 sky130_fd_sc_hd__dfxtp_4
X18 clk _000_ VGND VNB VPB VPWR out.0 sky130_fd_sc_hd__dfxtp_4
X19 rst VGND VNB VPB VPWR _020_ sky130_fd_sc_hd__inv_2
X20 rst VGND VNB VPB VPWR _019_ sky130_fd_sc_hd__inv_2
X21 _056_ _058_ VGND VNB VPB VPWR _016_ sky130_fd_sc_hd__nor2b_2
X22 clk VGND VNB VPB VPWR clkn sky130_fd_sc_hd__inv_2
X23 _062_ _051_ VGND VNB VPB VPWR _015_ sky130_fd_sc_hd__nand2b_2
X24 _058_ next_6_ VGND VNB VPB VPWR _051_ sky130_fd_sc_hd__nand2b_2
X25 _035_ _050_ VGND VNB VPB VPWR _014_ sky130_fd_sc_hd__nor2_2
X26 _049_ _030_ VGND VNB VPB VPWR _050_ sky130_fd_sc_hd__nor2b_2
X27 _040_ next_5_ VGND VNB VPB VPWR _049_ sky130_fd_sc_hd__nor2b_2
X28 _035_ _048_ VGND VNB VPB VPWR _013_ sky130_fd_sc_hd__nor2_2
X29 _047_ _026_ VGND VNB VPB VPWR _048_ sky130_fd_sc_hd__nor2b_2
X30 _040_ next_4_ VGND VNB VPB VPWR _047_ sky130_fd_sc_hd__nor2b_2
X31 _035_ _046_ VGND VNB VPB VPWR _012_ sky130_fd_sc_hd__nor2_2
X32 _045_ _022_ VGND VNB VPB VPWR _046_ sky130_fd_sc_hd__nor2b_2
X33 _040_ next_3_ VGND VNB VPB VPWR _045_ sky130_fd_sc_hd__nor2b_2
X34 _035_ _044_ VGND VNB VPB VPWR _011_ sky130_fd_sc_hd__nor2_2
X35 _043_ _081_ VGND VNB VPB VPWR _044_ sky130_fd_sc_hd__nor2b_2
X36 _040_ next_2_ VGND VNB VPB VPWR _043_ sky130_fd_sc_hd__nor2b_2
X37 _062_ _042_ VGND VNB VPB VPWR _010_ sky130_fd_sc_hd__nor2_2
X38 _041_ _077_ VGND VNB VPB VPWR _042_ sky130_fd_sc_hd__nor2b_2
X39 _040_ next_1_ VGND VNB VPB VPWR _041_ sky130_fd_sc_hd__nor2b_2
X40 _057_ VGND VNB VPB VPWR _040_ sky130_fd_sc_hd__buf_2
X41 _062_ _039_ VGND VNB VPB VPWR _009_ sky130_fd_sc_hd__nor2_2
X42 _038_ _072_ VGND VNB VPB VPWR _039_ sky130_fd_sc_hd__nor2b_2
X43 _076_ next_0_ VGND VNB VPB VPWR _038_ sky130_fd_sc_hd__nor2b_2
X44 _035_ _037_ VGND VNB VPB VPWR _008_ sky130_fd_sc_hd__nor2_2
X45 _036_ _064_ VGND VNB VPB VPWR _037_ sky130_fd_sc_hd__nor2b_2
X46 _058_ shift_0_ VGND VNB VPB VPWR _036_ sky130_fd_sc_hd__nor2b_2
X47 state_0_ VGND VNB VPB VPWR _035_ sky130_fd_sc_hd__buf_2
X48 _062_ _034_ VGND VNB VPB VPWR _007_ sky130_fd_sc_hd__nand2b_2
X49 outn.7 _033_ VGND VNB VPB VPWR _034_ sky130_fd_sc_hd__nand2b_2
X50 _030_ _066_ VGND VNB VPB VPWR _033_ sky130_fd_sc_hd__nand2b_2
X51 out.7 VGND VNB VPB VPWR outn.7 sky130_fd_sc_hd__inv_2
X52 _032_ VGND VNB VPB VPWR _006_ sky130_fd_sc_hd__inv_2
X53 _029_ _031_ _060_ VGND VNB VPB VPWR _032_ sky130_fd_sc_hd__nand3b_2
X54 out.6 _030_ VGND VNB VPB VPWR _031_ sky130_fd_sc_hd__nand2b_2
X55 next_6_ _057_ VGND VNB VPB VPWR _030_ sky130_fd_sc_hd__nand2_4
X56 cmp _026_ VGND VNB VPB VPWR _029_ sky130_fd_sc_hd__nor2_2
X57 out.6 VGND VNB VPB VPWR outn.6 sky130_fd_sc_hd__inv_2
X58 _028_ VGND VNB VPB VPWR _005_ sky130_fd_sc_hd__inv_2
X59 _025_ _027_ _068_ VGND VNB VPB VPWR _028_ sky130_fd_sc_hd__nand3b_2
X60 out.5 _026_ VGND VNB VPB VPWR _027_ sky130_fd_sc_hd__nand2b_2
X61 next_5_ _076_ VGND VNB VPB VPWR _026_ sky130_fd_sc_hd__nand2_4
X62 _070_ _022_ VGND VNB VPB VPWR _025_ sky130_fd_sc_hd__nor2_2
X63 out.5 VGND VNB VPB VPWR outn.5 sky130_fd_sc_hd__inv_2
X64 _024_ VGND VNB VPB VPWR _004_ sky130_fd_sc_hd__inv_2
X65 _084_ _023_ _060_ VGND VNB VPB VPWR _024_ sky130_fd_sc_hd__nand3b_2
X66 out.4 _022_ VGND VNB VPB VPWR _023_ sky130_fd_sc_hd__nand2b_2
X67 next_4_ _076_ VGND VNB VPB VPWR _022_ sky130_fd_sc_hd__nand2_4
X68 _070_ _081_ VGND VNB VPB VPWR _084_ sky130_fd_sc_hd__nor2_2
X69 out.4 VGND VNB VPB VPWR outn.4 sky130_fd_sc_hd__inv_2
X70 _083_ VGND VNB VPB VPWR _003_ sky130_fd_sc_hd__inv_2
X71 _080_ _082_ _068_ VGND VNB VPB VPWR _083_ sky130_fd_sc_hd__nand3b_2
X72 out.3 _081_ VGND VNB VPB VPWR _082_ sky130_fd_sc_hd__nand2b_2
X73 next_3_ _076_ VGND VNB VPB VPWR _081_ sky130_fd_sc_hd__nand2_4
X74 _070_ _077_ VGND VNB VPB VPWR _080_ sky130_fd_sc_hd__nor2_2
X75 out.3 VGND VNB VPB VPWR outn.3 sky130_fd_sc_hd__inv_2
X76 _079_ VGND VNB VPB VPWR _002_ sky130_fd_sc_hd__inv_2
X77 _075_ _078_ _068_ VGND VNB VPB VPWR _079_ sky130_fd_sc_hd__nand3b_2
X78 out.2 _077_ VGND VNB VPB VPWR _078_ sky130_fd_sc_hd__nand2b_2
X79 next_2_ _076_ VGND VNB VPB VPWR _077_ sky130_fd_sc_hd__nand2_4
X80 state_2_ VGND VNB VPB VPWR _076_ sky130_fd_sc_hd__buf_2
X81 _070_ _072_ VGND VNB VPB VPWR _075_ sky130_fd_sc_hd__nor2_2
X82 out.2 VGND VNB VPB VPWR outn.2 sky130_fd_sc_hd__inv_2
X83 _074_ VGND VNB VPB VPWR _001_ sky130_fd_sc_hd__inv_2
X84 _071_ _073_ _068_ VGND VNB VPB VPWR _074_ sky130_fd_sc_hd__nand3b_2
X85 out.1 _072_ VGND VNB VPB VPWR _073_ sky130_fd_sc_hd__nand2b_2
X86 next_1_ _057_ VGND VNB VPB VPWR _072_ sky130_fd_sc_hd__nand2_4
X87 _070_ _064_ VGND VNB VPB VPWR _071_ sky130_fd_sc_hd__nor2_2
X88 cmp VGND VNB VPB VPWR _070_ sky130_fd_sc_hd__buf_2
X89 out.1 VGND VNB VPB VPWR outn.1 sky130_fd_sc_hd__inv_2
X90 _069_ VGND VNB VPB VPWR _000_ sky130_fd_sc_hd__inv_2
X91 _065_ _067_ _068_ VGND VNB VPB VPWR _069_ sky130_fd_sc_hd__nand3_2
X92 _060_ VGND VNB VPB VPWR _068_ sky130_fd_sc_hd__buf_2
X93 _066_ shift_0_ _058_ VGND VNB VPB VPWR _067_ sky130_fd_sc_hd__nand3_2
X94 cmp VGND VNB VPB VPWR _066_ sky130_fd_sc_hd__inv_2
X95 out.0 _064_ VGND VNB VPB VPWR _065_ sky130_fd_sc_hd__nand2b_2
X96 next_0_ _057_ VGND VNB VPB VPWR _064_ sky130_fd_sc_hd__nand2_4
X97 out.0 VGND VNB VPB VPWR outn.0 sky130_fd_sc_hd__inv_2
X98 done _063_ VGND VNB VPB VPWR _017_ sky130_fd_sc_hd__nand2b_2
X99 start _062_ VGND VNB VPB VPWR _063_ sky130_fd_sc_hd__nand2b_2
X100 state_0_ VGND VNB VPB VPWR _062_ sky130_fd_sc_hd__buf_2
X101 _059_ _061_ VGND VNB VPB VPWR _018_ sky130_fd_sc_hd__nand2_4
X102 _060_ start VGND VNB VPB VPWR _061_ sky130_fd_sc_hd__nand2b_2
X103 state_0_ VGND VNB VPB VPWR _060_ sky130_fd_sc_hd__inv_2
X104 _056_ _058_ VGND VNB VPB VPWR _059_ sky130_fd_sc_hd__nand2_4
X105 _057_ VGND VNB VPB VPWR _058_ sky130_fd_sc_hd__buf_2
X106 state_2_ VGND VNB VPB VPWR _057_ sky130_fd_sc_hd__buf_2
X107 _052_ _053_ _054_ _055_ VGND VNB VPB VPWR _056_ sky130_fd_sc_hd__nand4_2
X108 next_4_ next_3_ VGND VNB VPB VPWR _055_ sky130_fd_sc_hd__nor2_2
X109 next_6_ next_5_ VGND VNB VPB VPWR _054_ sky130_fd_sc_hd__nor2_2
X110 next_2_ next_1_ VGND VNB VPB VPWR _053_ sky130_fd_sc_hd__nor2_2
X111 next_0_ shift_0_ VGND VNB VPB VPWR _052_ sky130_fd_sc_hd__nor2b_2
X112 rst VGND VNB VPB VPWR _021_ sky130_fd_sc_hd__inv_2
.ENDS SAR

************************
* end of SPICE netlist *
************************
