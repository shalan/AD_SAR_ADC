* SPICE netlist generated by Yosys 0.9 (git sha1 UNKNOWN, clang 12.0.0 -fPIC -Os)

.SUBCKT latch_nor3 CLK VP VN Q Qb VGND VNB VPB VPWR
X0 CLK VN Qb VGND VNB VPB VPWR Q sky130_fd_sc_hvl__nor3_1
X1 CLK VP Q VGND VNB VPB VPWR Qb sky130_fd_sc_hvl__nor3_1
.ENDS latch_nor3

.SUBCKT latch_nand3 CLK VP VN Q Qb VGND VNB VPB VPWR
X0 Q0b VGND VNB VPB VPWR Q sky130_fd_sc_hvl__inv_4
X1 Q0 VGND VNB VPB VPWR Qb sky130_fd_sc_hvl__inv_4
X2 CLK VN Q0b VGND VNB VPB VPWR Q0 sky130_fd_sc_hvl__nand3_1
X3 CLK VP Q0 VGND VNB VPB VPWR Q0b sky130_fd_sc_hvl__nand3_1
.ENDS latch_nand3

.SUBCKT ACMP_HVL clk INP INN Q VGND VNB VPB VPWR
X0 Q1 Q2 Q VGND VNB VPB VPWR Qb sky130_fd_sc_hvl__nor3_1
X1 Q1b Q2b Qb VGND VNB VPB VPWR Q sky130_fd_sc_hvl__nor3_1
X2 clkb INN Q2b VGND VNB VPB VPWR Q2 sky130_fd_sc_hvl__nor3_1
X3 clkb INP Q2 VGND VNB VPB VPWR Q2b sky130_fd_sc_hvl__nor3_1
X4 x1.Q0b VGND VNB VPB VPWR Q1 sky130_fd_sc_hvl__inv_4
X5 x1.Q0 VGND VNB VPB VPWR Q1b sky130_fd_sc_hvl__inv_4
X6 clk INN x1.Q0b VGND VNB VPB VPWR x1.Q0 sky130_fd_sc_hvl__nand3_1
X7 clk INP x1.Q0 VGND VNB VPB VPWR x1.Q0b sky130_fd_sc_hvl__nand3_1
X8 clk VGND VNB VPB VPWR clkb sky130_fd_sc_hvl__inv_1
.ENDS ACMP_HVL

************************
* end of SPICE netlist *
************************
